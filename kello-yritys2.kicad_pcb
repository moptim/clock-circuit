# Repository moptim/clock-circuit

## KiCad design kello-yritys2.kicad_pcb

Parts:
C1: 100uF; CP_Elec_6.3x7.7
C3, C8: 100nF; C_0805_2012Metric
J1: Conn_01x02_Male_To_Opto; PinHeader_1x03_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J3: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J4: Barrel_Jack; BarrelJack_Horizontal
Q1: TEPT4400; LED_D3.0mm_Front
R1: 1k; R_0805_2012Metric
R3: 27k; R_0805_2012Metric
R4: 10k; R_0805_2012Metric
U1: ATmega328PB-AU; TQFP-32_7x7mm_P0.8mm

Connections:
+5V: C1.1, C3.1, C8.1, J1.1, J2.1 (VBUS), J3.2 (VCC), J4.1, R3.1, R4.2, U1.4 (VCC), U1.18 (AVCC), U1.20 (AREF); also elsewhere on the board
/DbdPb/BtnOut: U1.3 (PE0); also elsewhere on the board
/Naytto/Ghi0: U1.32 (PD2); also elsewhere on the board
/Naytto/Ghi1: U1.31 (PD1); also elsewhere on the board
/Naytto/Ghi2: U1.1 (PD3); also elsewhere on the board
/Naytto/Ghi3: U1.2 (PD4); also elsewhere on the board
/Naytto/Glo0: U1.9 (PD5); also elsewhere on the board
/Naytto/Glo1: U1.8 (XTAL2/PB7); also elsewhere on the board
/Naytto/Glo2: U1.7 (XTAL1/PB6); also elsewhere on the board
/Naytto/Glo3: J3.4 (MOSI), U1.15 (PB3); also elsewhere on the board
/Naytto/Glo4: J3.3 (SCK), U1.17 (PB5); also elsewhere on the board
/Naytto/Glo5: J3.1 (MISO), U1.16 (PB4); also elsewhere on the board
/Naytto/Glo6: U1.14 (PB2); also elsewhere on the board
/Naytto/Glo7: U1.13 (PB1); also elsewhere on the board
/Naytto/Glo8: U1.11 (PD7); also elsewhere on the board
/Naytto/Glo9: U1.10 (PD6); also elsewhere on the board
/Naytto/GloA: U1.12 (PB0); also elsewhere on the board
/Naytto/GloB: U1.30 (PD0); also elsewhere on the board
/sheet5E8135E4/BtnOut: U1.6 (PE1); also elsewhere on the board
Earth: C1.2, C3.2, C8.2, J1.3, J2.5 (GND), J2.6 (Shield), J3.6 (GND), J4.2, J4.3, Q1.2 (E), U1.5 (GND), U1.21 (GND); also elsewhere on the board
unnamed: J1.2, R1.2
unnamed: J3.5 (~RST), R4.1, U1.29 (~RESET~/PC6)
unnamed: Q1.1 (C), R3.2, U1.23 (PC0)
unnamed: R1.1, U1.19 (PE2)

Parts:
C2, C5, C9, C10: 100n; C_0805_2012Metric
C4: 100u; CP_Elec_6.3x7.7
D1, D2: LED_Small_ALT; LED_D3.0mm_Front
Q2, Q3, Q4, Q5: IRLML6402; SOT-23
R17, R31, R34, R36: 270; R_0805_2012Metric
R18, R32, R35, R37: 1M; R_0805_2012Metric

Connections:
+5V: C2.1, C4.1, C5.1, C9.1, C10.1, Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R18.1, R32.1, R35.1, R37.1; also elsewhere on the board
/Naytto/Ghi0: R17.2; also elsewhere on the board
/Naytto/Ghi1: R31.2; also elsewhere on the board
/Naytto/Ghi2: R34.2; also elsewhere on the board
/Naytto/Ghi3: R36.2; also elsewhere on the board
/Naytto/Numero/Anode: Q2.3 (D); also elsewhere on the board
/Naytto/sheet5E58E229/Collector: D2.1 (K); also elsewhere on the board
/Naytto/sheet5E62C9E3/Anode: Q4.3 (D); also elsewhere on the board
/Naytto/sheet5E6237CA/Anode: D1.2 (A), Q3.3 (D); also elsewhere on the board
/Naytto/sheet5E6352C9/Anode: Q5.3 (D); also elsewhere on the board
Earth: C2.2, C4.2, C5.2, C9.2, C10.2; also elsewhere on the board
unnamed: D1.1 (K), D2.2 (A)
unnamed: Q2.1 (G), R17.1, R18.2
unnamed: Q3.1 (G), R31.1, R32.2
unnamed: Q4.1 (G), R34.1, R35.2
unnamed: Q5.1 (G), R36.1, R37.2

Parts:
C6: 100n; C_0805_2012Metric
R90: 100; R_0805_2012Metric
R91: 1k; R_0805_2012Metric
SW1: SW_Push_Dual; SW_Tactile_Straight_KSA0Axx1LFTR

Connections:
+5V: R91.1; also elsewhere on the board
/DbdPb/BtnOut: C6.2, R91.2, SW1.2, SW1.4; also elsewhere on the board
Earth: C6.1, R90.1; also elsewhere on the board
unnamed: R90.2, SW1.1, SW1.3

Parts of its further copies:
C7: 100n; C_0805_2012Metric
R92: 100; R_0805_2012Metric
R93: 1k; R_0805_2012Metric
SW2: SW_Push_Dual; SW_Tactile_Straight_KSA0Axx1LFTR

Connections of its further copies:
+5V: R93.1; also elsewhere on the board
/sheet5E8135E4/BtnOut: C7.2, R93.2, SW2.2; also elsewhere on the board
Earth: C7.1, R92.1; also elsewhere on the board
unnamed: R92.2, SW2.1

Parts:
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22: LED_Small_ALT; LED_D3.0mm_Front

Connections:
/Naytto/Numero/Anode: D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D14.2 (A), D18.2 (A), D20.2 (A); also elsewhere on the board
/Naytto/Numero/Cat0: D10.1 (K); also elsewhere on the board
/Naytto/Numero/Cat1: D11.1 (K); also elsewhere on the board
/Naytto/Numero/Cat2: D12.1 (K); also elsewhere on the board
/Naytto/Numero/Cat3a: D13.1 (K); also elsewhere on the board
/Naytto/Numero/Cat3b: D14.1 (K); also elsewhere on the board
/Naytto/Numero/Cat4: D15.1 (K); also elsewhere on the board
/Naytto/Numero/Cat5: D16.1 (K); also elsewhere on the board
/Naytto/Numero/Cat6a: D17.1 (K); also elsewhere on the board
/Naytto/Numero/Cat6b: D18.1 (K); also elsewhere on the board
/Naytto/Numero/Cat7: D19.1 (K); also elsewhere on the board
/Naytto/Numero/Cat8: D20.1 (K); also elsewhere on the board
/Naytto/Numero/Cat9: D21.1 (K); also elsewhere on the board
/Naytto/Numero/CatA: D22.1 (K); also elsewhere on the board
unnamed: D3.1 (K), D13.2 (A)
unnamed: D4.1 (K), D15.2 (A)
unnamed: D5.1 (K), D16.2 (A)
unnamed: D6.1 (K), D17.2 (A)
unnamed: D7.1 (K), D19.2 (A)
unnamed: D8.1 (K), D21.2 (A)
unnamed: D9.1 (K), D22.2 (A)

Parts of its further copies:
D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82: LED_Small_ALT; LED_D3.0mm_Front

Connections of its further copies:
/Naytto/Numero/Cat0: D30.1 (K), D50.1 (K), D70.1 (K); also elsewhere on the board
/Naytto/Numero/Cat1: D31.1 (K), D51.1 (K), D71.1 (K); also elsewhere on the board
/Naytto/Numero/Cat2: D32.1 (K), D52.1 (K), D72.1 (K); also elsewhere on the board
/Naytto/Numero/Cat3a: D33.1 (K), D53.1 (K), D73.1 (K); also elsewhere on the board
/Naytto/Numero/Cat3b: D34.1 (K), D54.1 (K), D74.1 (K); also elsewhere on the board
/Naytto/Numero/Cat4: D35.1 (K), D55.1 (K), D75.1 (K); also elsewhere on the board
/Naytto/Numero/Cat5: D36.1 (K), D56.1 (K), D76.1 (K); also elsewhere on the board
/Naytto/Numero/Cat6a: D37.1 (K), D57.1 (K), D77.1 (K); also elsewhere on the board
/Naytto/Numero/Cat6b: D38.1 (K), D58.1 (K), D78.1 (K); also elsewhere on the board
/Naytto/Numero/Cat7: D39.1 (K), D59.1 (K), D79.1 (K); also elsewhere on the board
/Naytto/Numero/Cat8: D40.1 (K), D60.1 (K), D80.1 (K); also elsewhere on the board
/Naytto/Numero/Cat9: D41.1 (K), D61.1 (K), D81.1 (K); also elsewhere on the board
/Naytto/Numero/CatA: D42.1 (K), D62.1 (K), D82.1 (K); also elsewhere on the board
/Naytto/sheet5E62C9E3/Anode: D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D54.2 (A), D58.2 (A), D60.2 (A); also elsewhere on the board
/Naytto/sheet5E6237CA/Anode: D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), D34.2 (A), D38.2 (A), D40.2 (A); also elsewhere on the board
/Naytto/sheet5E6352C9/Anode: D63.2 (A), D64.2 (A), D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), D74.2 (A), D78.2 (A), D80.2 (A); also elsewhere on the board
unnamed: D23.1 (K), D33.2 (A)
unnamed: D24.1 (K), D35.2 (A)
unnamed: D25.1 (K), D36.2 (A)
unnamed: D26.1 (K), D37.2 (A)
unnamed: D27.1 (K), D39.2 (A)
unnamed: D28.1 (K), D41.2 (A)
unnamed: D29.1 (K), D42.2 (A)
unnamed: D43.1 (K), D53.2 (A)
unnamed: D44.1 (K), D55.2 (A)
unnamed: D45.1 (K), D56.2 (A)
unnamed: D46.1 (K), D57.2 (A)
unnamed: D47.1 (K), D59.2 (A)
unnamed: D48.1 (K), D61.2 (A)
unnamed: D49.1 (K), D62.2 (A)
unnamed: D63.1 (K), D73.2 (A)
unnamed: D64.1 (K), D75.2 (A)
unnamed: D65.1 (K), D76.2 (A)
unnamed: D66.1 (K), D77.2 (A)
unnamed: D67.1 (K), D79.2 (A)
unnamed: D68.1 (K), D81.2 (A)
unnamed: D69.1 (K), D82.2 (A)

Parts:
Q6, Q7: BC850; SOT-23
R5: 5.6k; R_0805_2012Metric
R6: 15; R_0805_2012Metric

Connections:
/Naytto/Glo0: R5.2; also elsewhere on the board
/Naytto/Numero/Cat0: Q7.3 (C); also elsewhere on the board
Earth: Q6.2 (E), R6.2; also elsewhere on the board
unnamed: Q6.1 (B), Q7.2 (E), R6.1
unnamed: Q6.3 (C), Q7.1 (B), R5.1

Parts of its further copies:
Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32, Q33: BC850; SOT-23
R7, R9, R11, R13, R15, R19, R21, R23, R25, R27, R29, R33, R39: 5.6k; R_0805_2012Metric
R8, R10, R12, R14, R16, R20, R22, R24, R26, R28, R30, R38, R40: 15; R_0805_2012Metric

Connections of its further copies:
/Naytto/Glo1: R7.2; also elsewhere on the board
/Naytto/Glo2: R9.2; also elsewhere on the board
/Naytto/Glo3: R11.2, R13.2; also elsewhere on the board
/Naytto/Glo4: R15.2; also elsewhere on the board
/Naytto/Glo5: R19.2; also elsewhere on the board
/Naytto/Glo6: R21.2, R23.2; also elsewhere on the board
/Naytto/Glo7: R25.2; also elsewhere on the board
/Naytto/Glo8: R27.2; also elsewhere on the board
/Naytto/Glo9: R29.2; also elsewhere on the board
/Naytto/GloA: R33.2; also elsewhere on the board
/Naytto/GloB: R39.2; also elsewhere on the board
/Naytto/Numero/Cat1: Q9.3 (C); also elsewhere on the board
/Naytto/Numero/Cat2: Q11.3 (C); also elsewhere on the board
/Naytto/Numero/Cat3a: Q13.3 (C); also elsewhere on the board
/Naytto/Numero/Cat3b: Q15.3 (C); also elsewhere on the board
/Naytto/Numero/Cat4: Q17.3 (C); also elsewhere on the board
/Naytto/Numero/Cat5: Q19.3 (C); also elsewhere on the board
/Naytto/Numero/Cat6a: Q21.3 (C); also elsewhere on the board
/Naytto/Numero/Cat6b: Q23.3 (C); also elsewhere on the board
/Naytto/Numero/Cat7: Q25.3 (C); also elsewhere on the board
/Naytto/Numero/Cat8: Q27.3 (C); also elsewhere on the board
/Naytto/Numero/Cat9: Q29.3 (C); also elsewhere on the board
/Naytto/Numero/CatA: Q31.3 (C); also elsewhere on the board
/Naytto/sheet5E58E229/Collector: Q33.3 (C); also elsewhere on the board
Earth: Q8.2 (E), Q10.2 (E), Q12.2 (E), Q14.2 (E), Q16.2 (E), Q18.2 (E), Q20.2 (E), Q22.2 (E), Q24.2 (E), Q26.2 (E), Q28.2 (E), Q30.2 (E), Q32.2 (E), R8.2, R10.2, R12.2, R14.2, R16.2, R20.2, R22.2, R24.2, R26.2, R28.2, R30.2, R38.2, R40.2; also elsewhere on the board
unnamed: Q8.1 (B), Q9.2 (E), R8.1
unnamed: Q8.3 (C), Q9.1 (B), R7.1
unnamed: Q10.1 (B), Q11.2 (E), R10.1
unnamed: Q10.3 (C), Q11.1 (B), R9.1
unnamed: Q12.1 (B), Q13.2 (E), R12.1
unnamed: Q12.3 (C), Q13.1 (B), R11.1
unnamed: Q14.1 (B), Q15.2 (E), R14.1
unnamed: Q14.3 (C), Q15.1 (B), R13.1
unnamed: Q16.1 (B), Q17.2 (E), R16.1
unnamed: Q16.3 (C), Q17.1 (B), R15.1
unnamed: Q18.1 (B), Q19.2 (E), R20.1
unnamed: Q18.3 (C), Q19.1 (B), R19.1
unnamed: Q20.1 (B), Q21.2 (E), R22.1
unnamed: Q20.3 (C), Q21.1 (B), R21.1
unnamed: Q22.1 (B), Q23.2 (E), R24.1
unnamed: Q22.3 (C), Q23.1 (B), R23.1
unnamed: Q24.1 (B), Q25.2 (E), R26.1
unnamed: Q24.3 (C), Q25.1 (B), R25.1
unnamed: Q26.1 (B), Q27.2 (E), R28.1
unnamed: Q26.3 (C), Q27.1 (B), R27.1
unnamed: Q28.1 (B), Q29.2 (E), R30.1
unnamed: Q28.3 (C), Q29.1 (B), R29.1
unnamed: Q30.1 (B), Q31.2 (E), R38.1
unnamed: Q30.3 (C), Q31.1 (B), R33.1
unnamed: Q32.1 (B), Q33.2 (E), R40.1
unnamed: Q32.3 (C), Q33.1 (B), R39.1

Board: 2 copper layers, 189.2 x 105.4 mm, 176 parts (1 on the bottom side), 105 nets.

Other parts of the board:
C11: 100u; CP_Elec_6.3x7.7

Their connections:
+5V: C11.1; also elsewhere on the board
Earth: C11.2; also elsewhere on the board

## KiCad design kello-zcdetector/kello-zcdetector.kicad_pcb

Parts:
D1: D_Bridge_+-AA; Diode_Bridge_Diotec_SO-DIL-Slim
F1, F2: Fuse; Fuse_10mmx3mm
J1: Conn_01x02_Male; AC_connector
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4: 100k; R_0805_2012Metric
U1: LTV-817S; SMDIP-4_W9.53mm

Connections:
unnamed: D1.1, U1.1
unnamed: D1.2, U1.2
unnamed: D1.3, R3.1
unnamed: D1.4, R4.1
unnamed: F1.1, R2.2
unnamed: F1.2, J1.2
unnamed: F2.1, J1.1
unnamed: F2.2, R1.2
unnamed: J2.1, U1.3
unnamed: J2.2, U1.4
unnamed: R1.1, R3.2
unnamed: R2.1, R4.2

Board: 2 copper layers, 45.0 x 21.6 mm, 11 parts (0 on the bottom side), 12 nets.

Other parts of the board:
MOUNT: MountingHole_2.2mm_M2

## KiCad design isp-molex-adapter/isp-molex-adapter.kicad_pcb

Parts:
D1, D2: LED_Small; R_0805_2012Metric
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: AVR-ISP-10; PinHeader_2x05_P2.54mm_Vertical
J3: AVR-ISP-6; Molex_Pico-Clasp_202396-0607_1x06-1MP_P1.00mm_Horizontal
Q1, Q2: BC850; SOT-23
R1, R2: 100k; R_0805_2012Metric
R3, R4, R5, R6: 5.6k; R_0805_2012Metric

Connections:
+5V: D1.2 (A), D2.2 (A), J1.2 (VCC), J2.2 (VCC), J3.2 (VCC)
Earth: J1.6 (GND), J2.4 (GND), J2.6 (GND), J2.8 (GND), J2.10 (GND), J3.6 (GND), Q1.2 (E), Q2.2 (E)
unnamed: D1.1 (K), R3.2, R4.2
unnamed: D2.1 (K), R5.2, R6.2
unnamed: J1.1 (MISO), J2.9 (MISO), J3.1 (MISO), R2.2
unnamed: J1.3 (SCK), J2.7 (SCK), J3.3 (SCK)
unnamed: J1.4 (MOSI), J2.1 (MOSI), J3.4 (MOSI), R1.2
unnamed: J1.5 (~RST), J2.5 (~RST), J3.5 (~RST)
unnamed: Q1.1 (B), R1.1
unnamed: Q1.3 (C), R3.1, R4.1
unnamed: Q2.1 (B), R2.1
unnamed: Q2.3 (C), R5.1, R6.1

Board: 2 copper layers, 24.1 x 14.0 mm, 13 parts (0 on the bottom side), 12 nets.

## Commit log

2022-02-24 nonni
2022-02-24 jemmataas nää hetkeks
2022-02-24 ei niin pahan näköne
2022-02-24 diodisillalla zcdet
2022-02-24 isp molex adapter
2022-02-24 jawohl
2022-02-24 tilasin nää
